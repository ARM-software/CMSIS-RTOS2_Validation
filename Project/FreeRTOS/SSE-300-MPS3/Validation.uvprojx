# Keil uVision project Validation.uvprojx, settings and files
target SSE-300-MPS3 (6160000::V6.16::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: Validation
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\Include;.\RTE\CMSIS_RTOS2_Validation
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --summary_stderr --info summarysizes --load_addr_map_info --entry=Reset_Handler
  group Source Files
    ../../: main.c retarget_stdio.c
  group Documentation
    ../../../: README.md
  group CMSIS-RTOS2_Validation
    ../../../Source/: cmsis_rv2.c RV2_Kernel.c RV2_Thread.c RV2_ThreadFlags.c RV2_GenWait.c RV2_Timer.c RV2_EventFlags.c RV2_Mutex.c RV2_Semaphore.c RV2_MemoryPool.c RV2_MessageQueue.c RV2_Common.c
    ./RTE/CMSIS_RTOS2_Validation/: RV2_Config.c RV2_Config.h RV2_Config_Device.h
  group Validation Framework
    ../../../Source/: tf_main.c tf_report.c
software components: RTOS:Config 10.4.6, RTOS:Core 10.4.6, RTOS:Event Groups 10.4.6, RTOS:Heap 10.4.6, RTOS:Timers 10.4.6, CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS2:FreeRTOS 10.4.6, Device:Definition 1.1.0, Device:Startup 1.1.0, Native Driver:UART 1.0.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
